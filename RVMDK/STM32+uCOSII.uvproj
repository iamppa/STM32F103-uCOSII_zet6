# Keil uVision project STM32+uCOSII.uvproj, settings and files
target FLASH (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: STM32+uCOSII +hex
  AfterMake: M:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Obj/STM32+uCOSII.bin ./Obj/STM32+uCOSII.axf
  c flags: Optim=4 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\uCOSII\src;..\Libraries\uCOSII\port;..\Source\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004400 size 0x7bc00
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../Source/src/: led.c main.c stm32f10x_it.c uart_printf.c key.c ds18b20.c uart1_dma.c cabinet.c DataFlash.c utils.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_flash.c
  group ucos-ii
    ../Libraries/uCOSII/src/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../Libraries/uCOSII/port/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group RVMDK
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group inc
    ../Source/inc/: app_cfg.h led.h os_cfg.h stm32f10x_conf.h stm32f10x_it.h uart_printf.h key.h ds18b20.h uart1_dma.h io_config.h cabinet.h DataFlash.h utils.h
